# Keil uVision project 擂台机器人.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 矿山振动仪测试版 +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\KEY;..\HARDWARE\BEEP;..\HARDWARE\OLED;..\FATFS\exfuns;..\FATFS\src;..\FATFS\src\option;..\HARDWARE\EXTI;..\HARDWARE\ADC;..\HARDWARE\PWM;..\STM32F10x_FWLib\inc;..\HARDWARE\TIMER;..\HARDWARE\CAR;..\HARDWARE\CONFIG;..\HARDWARE\STMFLASH;..\HARDWARE\TIMER7;..\LOGIC\BSP_INIT;..\LOGIC\LOGIC
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group LOGIC
    ../LOGIC/BSP_INIT/: bsp_init.c
    ../LOGIC/LOGIC/: logic_qualifying.c logic_elimination.c
    ../HARDWARE/CONFIG/: config.h
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/OLED/: oled.c multilevel.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/CAR/: car.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/TIMER7/: timer_7.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c
  group DOC
    ../DOC/: 01.功能说明.txt 02GPIO分配表(按GPIO次序排列).txt 03.GPIO分配表(按功能排列).txt
